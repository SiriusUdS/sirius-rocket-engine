<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SIRIUS_Rocket_Engine.ewp</path>
  </project>
  <batchBuild />
</workspace>
